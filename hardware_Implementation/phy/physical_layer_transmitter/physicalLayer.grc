options:
  parameters:
    author: Ckjaer
    generate_options: qt_gui
    id: physical_layer_transmitter
    output_language: python
    title: acm_phy_layer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: bp_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: th.modcod(bandwidth, "7")/2 + 200
    low_cutoff_freq: '-th.modcod(bandwidth, "7")/2 - 200'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_RECTANGULAR
  states: {}
- name: bp_filter_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: bandwidth/2 + 200
    low_cutoff_freq: '-bandwidth/2 - 200'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_RECTANGULAR
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: int(np.ceil(samp_rate/(th.modcod(bandwidth, "1"))))
  states: {}
- name: repack_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (np.pi / 2) / 4
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (np.pi / 2) / interp
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_2
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate*2/(2*np.pi*bandwidth)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: repack_size
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: interpolation
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: repack_size
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: repack_size
    l: '8'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**15
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vco_f_1
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: samp_rate
    sensitivity: 2*np.pi*bandwidth/3
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.5, -0.5, 0.5, 1.5]'
  states: {}
- name: digital_symbol_sync_xx_1_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '64'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: interpolation
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: digital_symbol_sync_xx_1_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '64'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: interpolation
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: digital_symbol_sync_xx_1_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '64'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: interpolation
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import json

      class blk(gr.interp_block):  # other base classes are basic_block, decim_block, interp_block
          
          def __init__(self, addr = "modcod", interpolation = 10, samp_rate=32000, bandwidth = 25000):  # only default arguments here
              gr.interp_block.__init__(
                  self,
                  name='DEMUX',   # will show up in GRC
                  in_sig = [np.byte], 
                  out_sig = [np.byte, np.byte, np.byte],
                  interp = interpolation
              )
              self.addr = addr
              self._modcod = "1" # default modcod
              self.samp_rate = samp_rate
              self.bandwidth = bandwidth
              self.repack = 1
          
              # read MODCOD from json file      
              self.filename = "MODCOD.json"
              self.json_data = None
              
              
              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              self.message_out2 = 'repack_out'
              self.message_port_register_out(pmt.intern(self.message_out2))

              self.message_out3 = 'interp_out'
              self.message_port_register_out(pmt.intern(self.message_out3))


              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False

          @property
          def modcod(self):
              return self._modcod
          
          @modcod.setter
          def modcod(self, value: str):
              self._modcod = value
              repack = 1
              
              modcod_spect = self.json_data[self.modcod]["SPECT"]           
              throughput = modcod_spect*self.bandwidth
              if self.json_data[self.modcod]["MOD"] == "g4FSK":
                  repack = 2
                  throughput = 0.5*throughput # symbol rate conversion

              self._interp = int(np.ceil(self.samp_rate/throughput)) 

              # Define the interpolation rate globally using msg output
              interp = pmt.from_long(self._interp)
              interp_msg = pmt.cons(pmt.string_to_symbol("repack_size"), interp)
              self.message_port_pub(pmt.intern(self.message_out3), interp_msg)

              # Define the repack size globally using msg output
              if self.repack != repack:
                  self.repack = repack
                  repack = pmt.from_long(repack)
                  msg = pmt.cons(pmt.string_to_symbol("repack_size"), repack)
                  self.message_port_pub(pmt.intern(self.message_out2), msg)

          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname == "modcod":
                      pass
                  elif varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      if varname == "modcod":
                          r[varname] = self.modcod
                      else:
                          r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if varname == "modcod":
                          self.modcod = data[1][varname]
                          r[varname] = "ok"
                      elif type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))
         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)
                      
              # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")

              # Apply interpolation rate according to desired bitrate, if the modcod is g4FSK
              # the interpolation is doubled to account for repacking of bits       
              for i in range(len(input_items[0])):
                  for j in range(self._interp):
                      output_items[modcod_idx][i*self._interp + j] = input_items[0][i]
                  

              return len(output_items[0])
    addr: '''mux'''
    bandwidth: bandwidth
    interpolation: int(np.ceil(samp_rate/(th.modcod(bandwidth, "1"))))
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import json


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, addr = "modcod"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='DEMUX',   # will show up in GRC
                  in_sig = [np.complex64], 
                  out_sig = [np.complex64, np.complex64, np.complex64]
              )
              self.addr = addr
              self.modcod = "1" # default modcod
             

              # read MODCOD from json file
              self.filename = "MODCOD.json"
              self.json_data = None
              
              
              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))
              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))
         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)
                  
              # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              output_items[modcod_idx][:] = input_items[0][:] 

              return len(output_items[0])
    addr: '''demux'''
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, snr=10, addr="awgn"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='AWGN Channel',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.addr = addr
              self.snr = snr
              window_size = 100
              self.kernel = np.ones(window_size)/window_size

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))


          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):
              # Calculate the moving average of the signal power to determine the noise power
              data = input_items[0][:]
              signal_power = data.real**2 + data.imag**2 # convert to power
              signal_power_avg = np.convolve(signal_power, self.kernel , mode='same')[-1]
              noise_power = signal_power_avg / 10**(self.snr/10)

              # Debug messages
              # if self.nitems_written(0) % 100 == 0:
              #     print(f"Signal Power Average: {np.sqrt(signal_power_avg)}")
              #     print(f"Noise Power: {np.sqrt(noise_power)}")

              noise_vector = np.sqrt(noise_power) * (np.random.randn(len(input_items[0])) + 1j * np.random.randn(len(input_items[0])))
              output_items[0][:] = input_items[:] + noise_vector
              return len(output_items[0])
    addr: '"awgn"'
    snr: '20'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Scaling',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = (input_items[0] + 8)/4
              return len(output_items[0])
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import json


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, addr="modcod"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='MUX',   # will show up in GRC
                  in_sig = [np.complex64, np.complex64, np.complex64],
                  out_sig = [np.complex64]
              )
              self.addr = addr
              self.modcod = "8" # default modcod
              
              # read MODCOD from json file
              # file_name = 'MODCOD.json'
              self.filename = "MODCOD.json"
              self.json_data = None

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))
              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)

               # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              
              output_items[0][:] = input_items[modcod_idx] 
              
              return len(output_items[0])
    addr: '''mux_1'''
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import json


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, addr="modcod"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='MUX',   # will show up in GRC
                  in_sig = [np.byte, np.byte, np.byte],
                  out_sig = [np.byte]
              )
              self.addr = addr
              self.modcod = "1" # default modcod
              
              # read MODCOD from json file
              # file_name = 'MODCOD.json'
              self.filename = "MODCOD.json"
              self.json_data = None

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))
              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)

               # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              
              output_items[0][:] = input_items[modcod_idx][:] 
              
              return len(output_items[0])
    addr: '''demux_1'''
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, fft_size=2**15, bandwidth=500, samplerate = 32e3, addr = "snr_meas"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='SNR Measurement',   
                  in_sig = [(np.complex64, fft_size)],
                  out_sig = None 
              )
              self.addr = addr
              self.fft_size = fft_size
              self.samplerate = samplerate
              self.bandwidth = bandwidth
              self.snrAvg = 0
              
              self.snr = np.zeros(int((samplerate/fft_size)))
              self.window = int(0.5*(samplerate/fft_size)) # 0.5 s window
              self.kernel = np.ones(self.window) / self.window
              # self.portName = 'print_out'

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):        
              
              data = input_items[0][0][:]

              fft = np.fft.fft(data) * 1/self.fft_size
              fft_shifted = np.fft.fftshift(fft) 
              magsquared = fft_shifted.real**2 + fft_shifted.imag**2
              # print("fft")
              res = self.samplerate/self.fft_size
              span = int(self.bandwidth/res)
              center = int(self.fft_size/2)
              start =int( center - span/2)
              stop = int(center + span/2)
              sig = magsquared[start:stop]
             
              noise = np.append(magsquared[0:start-int(span/2)], magsquared[stop+int(span/2):])
              noise = span*np.mean(noise)
              # noise = magsquared[:span]

              # print(f"Range %i - %i, Noise %.3f, len: %i" % (start, stop, 10*np.log10(np.mean(sig)), len(sig)))
          
              noise_power = 10*np.log10(noise)
              receive_power = 10*np.log10(np.sum(sig))
              snr = receive_power - noise_power

              # Update the SNR buffer
              self.snr = self.snr[1:]
              self.snr = np.append(self.snr, snr)

              # Calculate the moving average of the SNR with convolution
              self.snrAvg = np.convolve(self.snr, self.kernel, mode='valid')[-1]
              print(self.snrAvg)
              # self.message_port_pub(pmt.intern(self.portName), pmt.to_pmt(self.snrAvg))
              #output_items[0][:] = 10*np.log10(magsquared) # To view the fft in vector sink

              return 1
    addr: '"snr_meas"'
    bandwidth: 25e3
    comment: Custom block
    fft_size: 2**15
    samplerate: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: bandwidth*2/3 + 200
    decim: '1'
    samp_rate: samp_rate
    taps: bp_filter_0
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: th.modcod(bandwidth, "7")/2 + th.modcod(bandwidth, "7")/6
    decim: '1'
    samp_rate: samp_rate
    taps: bp_filter
    type: fcc
  states: {state: disabled}
- name: g4fsk_decoding_0
  id: g4fsk_decoding
  parameters:
    movav: '30'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Gaussian filter
    interp: '1'
    taps: taps.generate_taps(4, 0.25)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Gaussian filter
    interp: '1'
    taps: taps.generate_taps(4, 0.25)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: taps
  id: epy_module
  parameters:
    comment: |-
      Calculates gaussian
      filter taps
    source_code: "import numpy as np\r\nfrom gnuradio import filter\r\n\r\ndef generate_taps(samples_per_symbol, bt):\r\n    samples_per_symbol = int(samples_per_symbol)\r\n    ntaps = 4 * samples_per_symbol\r\n\r\n    # Generate Gaussian filter taps\r\n    gaussian_taps = filter.firdes.gaussian(\r\n        1,                       # gain\r\n        samples_per_symbol,      # symbol_rate\r\n        bt,                      # bandwidth * symbol time\r\n        ntaps                    # number of taps\r\n    )\r\n\r\n    taps = np.convolve(np.array(gaussian_taps), np.ones(samples_per_symbol))\r\n    return taps"
  states: {}
- name: th
  id: epy_module
  parameters:
    comment: |-
      Calculates the throughput
      in bps for the selected 
      modcod
    source_code: "import json\r\nimport numpy as np\r\n\r\n\r\nfile_name = r\"C:\\Users\\chri0\\Documents\\GitHub\\SDR_Ground_Station\\hardwareImplementation\\phy\\physical_layer_transmitter\\MODCOD.json\"\r\n\r\ndata:dict\r\nwith open(file_name, 'r') as f:\r\n    data = json.load(f)\r\n\r\ndef modcod(bw, modcod):\r\n    spectral_eff = data[modcod][\"SPECT\"]\r\n    throughput = spectral_eff * bw\r\n    return throughput\r\n"
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: usrp
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: msg_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: msg_out2
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: msg_out3
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: msg_out4
  states: {}
- name: virtual_sink_2_1_0
  id: virtual_sink
  parameters:
    stream_id: msg_out6
  states: {}
- name: virtual_sink_2_1_1
  id: virtual_sink
  parameters:
    stream_id: msg_out5
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: usrp
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: msg_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: msg_out2
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: msg_out3
  states: {}
- name: virtual_source_1_1_0_1
  id: virtual_source
  parameters:
    stream_id: msg_out4
  states: {}
- name: virtual_source_1_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: msg_out5
  states: {}
- name: virtual_source_1_1_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: msg_out6
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:5557
    comment: Rx
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5558
    comment: Tx
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', epy_block_1_0_0, '2']
- [analog_frequency_modulator_fc_0_0, '0', epy_block_1_0_0, '1']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_1_0, '0']
- [analog_quadrature_demod_cf_1, '0', digital_symbol_sync_xx_1_0_0, '0']
- [analog_quadrature_demod_cf_2, '0', digital_symbol_sync_xx_1_0_0_0, '0']
- [analog_random_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_1_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_vco_f_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vco_f_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_1_0_0_0, '2']
- [digital_binary_slicer_fb_0_0, '0', epy_block_1_0_0_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_symbol_sync_xx_1_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_1_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_symbol_sync_xx_1_0_0_0, '0', g4fsk_decoding_0, '0']
- [epy_block_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [epy_block_0, '1', digital_chunks_to_symbols_xx_0_0, '0']
- [epy_block_0, '2', digital_chunks_to_symbols_xx_0, '0']
- [epy_block_0, interp_out, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, msg_out, virtual_sink_2, '0']
- [epy_block_0, repack_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_0_0, '0', analog_quadrature_demod_cf_2, '0']
- [epy_block_0_0, '1', analog_quadrature_demod_cf_1, '0']
- [epy_block_0_0, '2', analog_quadrature_demod_cf_0, '0']
- [epy_block_0_0, msg_out, virtual_sink_2_1, '0']
- [epy_block_0_0_0, '0', blocks_null_sink_0, '0']
- [epy_block_0_0_0, '0', virtual_sink_0, '0']
- [epy_block_0_0_0, msg_out, virtual_sink_2_0_0, '0']
- [epy_block_0_1, '0', blocks_vco_f_1, '0']
- [epy_block_1_0_0, '0', epy_block_0_0_0, '0']
- [epy_block_1_0_0, msg_out, virtual_sink_2_0, '0']
- [epy_block_1_0_0_0, '0', blocks_null_sink_1, '0']
- [epy_block_1_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_1_0_0_0, msg_out, virtual_sink_2_1_0, '0']
- [epy_block_2_0, msg_out, virtual_sink_2_1_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', epy_block_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', epy_block_1_0_0, '0']
- [g4fsk_decoding_0, '0', blocks_float_to_uchar_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [interp_fir_filter_xxx_0_0, '0', epy_block_0_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', epy_block_0_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_0, '0', epy_block_0, msg_in]
- [virtual_source_1_0_0, '0', epy_block_1_0_0, msg_in]
- [virtual_source_1_0_0_0, '0', epy_block_0_0_0, msg_in]
- [virtual_source_1_0_1, '0', epy_block_0_0, msg_in]
- [virtual_source_1_0_1_0, '0', epy_block_1_0_0_0, msg_in]
- [virtual_source_1_1, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0_1, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0_1_0, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0_1_0_0, '0', zeromq_pub_msg_sink_0, in]
- [zeromq_req_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [zeromq_sub_msg_source_0, out, virtual_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
