options:
  parameters:
    author: CS6 - 615
    generate_options: qt_gui
    id: physical_layer_transmitter
    output_language: python
    title: acm_phy_layer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: samp_rate/(sps*th.modcod(bandwidth, "1"))
  states: {}
- name: decimation_rx
  id: variable
  parameters:
    value: samp_rate/(sps*th.modcod(bandwidth, "1"))
  states: {}
- name: repack_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (np.pi / 2) / sps
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (np.pi / 2) / sps
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (np.pi/2)/sps
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_2
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate*2)/(2*np.pi*th.modcod(bandwidth, "9"))
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: repack_size
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: decimation
  states: {}
- name: blocks_msgpair_to_var_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: decimation_rx
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: repack_size
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: repack_size
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**15
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.5'
    samp_rate: samp_rate
    sensitivity: (2*np.pi*th.modcod(bandwidth, "9"))/1.5
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.5, -0.5, 0.5, 1.5]'
  states: {}
- name: digital_symbol_sync_xx_1_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.1'
    max_dev: '1.5'
    nfilters: '64'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_1_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '64'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: digital_symbol_sync_xx_1_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '64'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import json

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          
          def __init__(self, addr = "modcod", samp_rate=32000, bandwidth=25000, sps = 4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='DEMUX',   # will show up in GRC
                  in_sig = [np.byte], 
                  out_sig = [np.byte, np.byte, np.byte],
                  # interp = interpolation
              )
              self.addr = addr
              self._modcod = "1" # default modcod
              self.samp_rate = samp_rate
              self.bandwidth = bandwidth
              self.repack = 1
              self.decimation = 1
              self.sps = sps
              # read MODCOD from json file      
              self.filename = "MODCOD.json"
              self.json_data = None
              
              
              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              self.message_out2 = 'repack_out'
              self.message_port_register_out(pmt.intern(self.message_out2))

              self.message_out3 = 'decim_out'
              self.message_port_register_out(pmt.intern(self.message_out3))


              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False

          @property
          def modcod(self):
              return self._modcod
          
          @modcod.setter
          def modcod(self, value: str):
              self._modcod = value
              repack = 1
              
              modcod_spect = self.json_data[self.modcod]["SPECT"]     
              throughput = modcod_spect*self.bandwidth
              if self.json_data[self.modcod]["MOD"] == "g4FSK":
                  repack = 2
                  throughput = 0.5*throughput # symbol rate conversion
       
              # Calculate the decimation factor for the bitrate of the rational resampler
              self.decimation = self.samp_rate/(throughput*self.sps)
              
              # Define the interpolation rate globally using msg output
              decimation = pmt.to_pmt(self.decimation)
              decim_msg = pmt.cons(pmt.string_to_symbol("decimation"), decimation)
              self.message_port_pub(pmt.intern(self.message_out3), decim_msg)

              # Define the repack size globally using msg output       
              if self.repack != repack:
                  self.repack = repack
                  repack = pmt.from_long(repack)
                  msg = pmt.cons(pmt.string_to_symbol("repack_size"), repack)
                  self.message_port_pub(pmt.intern(self.message_out2), msg)

          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname == "modcod":
                      pass
                  elif varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      if varname == "modcod":
                          r[varname] = self.modcod
                      else:
                          r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if varname == "modcod":
                          self.modcod = data[1][varname]
                          r[varname] = "ok"
                      elif type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))
         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)
                      
              # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              # Transmit data to the desired modulation scheme, remaining sources received a
              # bitstream of 0's     
              output_items[modcod_idx][:] = input_items[0]   
              # for i in range(len(input_items[0])):
              #     for j in range(self._interp):
              #         output_items[modcod_idx][i*self._interp + j] = input_items[0][i]
                  

              return len(output_items[0])
    addr: '''mux'''
    bandwidth: bandwidth
    samp_rate: samp_rate
    sps: '4'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import json


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, addr = "modcod", samprate=32000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='DEMUX',   # will show up in GRC
                  in_sig = [np.complex64], 
                  out_sig = [np.complex64, np.complex64, np.complex64]
              )
              self.addr = addr
              self.modcod = "1" # default modcod
              self.sps = 4
              self.samp_rate = samprate

              # read MODCOD from json file
              self.filename = "MODCOD.json"
              self.json_data = None
              
              
              self.decimation = 1
              self.bandwidth = 25000
              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))
              self.message_out3 = 'decim_out'
              self.message_port_register_out(pmt.intern(self.message_out3))
              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def updatedecimate(self):
              print("Updating")
              modcod_spect = self.json_data[self.modcod]["SPECT"]     
              throughput = modcod_spect*self.bandwidth
              if self.json_data[self.modcod]["MOD"] == "g4FSK":
                  throughput = 0.5*throughput # symbol rate conversion
                     # Calculate the decimation factor for the bitrate of the rational resampler
              self.decimation = self.samp_rate/(throughput*self.sps)
              print(self.decimation)
              # Define the interpolation rate globally using msg output
              decimation = pmt.to_pmt(self.decimation)
              decim_msg = pmt.cons(pmt.string_to_symbol("decimation"), decimation)
              self.message_port_pub(pmt.intern(self.message_out3), decim_msg)

          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  print(varname)
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          if varname == "modcod":
                              self.updatedecimate()
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))
         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)
                  
              # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              output_items[modcod_idx][:] = input_items[0][:] 

              return len(output_items[0])
    addr: '''demux'''
    samprate: samp_rate
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import json


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, addr="modcod"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='MUX',   # will show up in GRC
                  in_sig = [np.complex64, np.complex64, np.complex64],
                  out_sig = [np.complex64]
              )
              self.addr = addr
              self.modcod = "1" # default modcod
              
              # read MODCOD from json file
              # file_name = 'MODCOD.json'
              self.filename = "MODCOD.json"
              self.json_data = None

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))
              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)

               # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              
              output_items[0][:] = input_items[modcod_idx] 
              
              return len(output_items[0])
    addr: '''mux_1'''
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import json


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, addr="modcod"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='MUX',   # will show up in GRC
                  in_sig = [np.byte, np.byte, np.byte],
                  out_sig = [np.byte]
              )
              self.addr = addr
              self.modcod = "1" # default modcod
              
              # read MODCOD from json file
              # file_name = 'MODCOD.json'
              self.filename = "MODCOD.json"
              self.json_data = None

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))
              
          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

         
          def work(self, input_items, output_items):
              if self.json_data == None:
                  with open(self.filename) as json_file:
                      self.json_data = json.load(json_file)

               # determine the appropriate modcod
              modcod_idx = self.json_data[self.modcod]["MOD"]
              match modcod_idx:
                  case "g4FSK":
                      modcod_idx = 0
                  case "MSK":
                      modcod_idx = 1
                  case "gMSK":
                      modcod_idx = 2
                  case _:
                      raise ValueError("Invalid modcod")
              
              output_items[0][:] = input_items[modcod_idx][:] 
              
              return len(output_items[0])
    addr: '''demux_1'''
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, fft_size=2**15, bandwidth=500, samplerate = 32e3, addr = "snr_meas"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='SNR Measurement',   
                  in_sig = [(np.complex64, fft_size)],
                  out_sig = None 
              )
              self.addr = addr
              self.fft_size = fft_size
              self.samplerate = samplerate
              self.bandwidth = bandwidth
              self.snrAvg = 0
              
              self.snr = np.zeros(int((samplerate/fft_size)))
              self.window = int(0.5*(samplerate/fft_size)) # 0.5 s window
              self.kernel = np.ones(self.window) / self.window

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):        
              
              data = input_items[0][0][:]

              fft = np.fft.fft(data) * 1/self.fft_size
              fft_shifted = np.fft.fftshift(fft) 
              magsquared = fft_shifted.real**2 + fft_shifted.imag**2
              res = self.samplerate/self.fft_size
              span = int(self.bandwidth/res)
              center = int(self.fft_size/2)
              start =int( center - span/2)
              stop = int(center + span/2)
              sig = magsquared[start:stop]

              
              offset_span = int(span) 
              noise = np.append(magsquared[0:start-offset_span], magsquared[stop+offset_span:])
              noise = span*np.mean(noise)

              # print(f"Range %i - %i, Noise %.3f, len: %i" % (start, stop, 10*np.log10(np.mean(sig)), len(sig)))
          
              noise_power = 10*np.log10(noise)
              receive_power = 10*np.log10(np.sum(sig))
              snr = receive_power - noise_power

              # Update the SNR buffer
              self.snr = self.snr[1:]
              self.snr = np.append(self.snr, snr)

              # Calculate the moving average of the SNR with convolution
              self.snrAvg = np.convolve(self.snr, self.kernel, mode='valid')[-1]
              # print(self.snrAvg)
              return 1
    addr: '"snr_meas"'
    bandwidth: 25e3
    fft_size: 2**15
    samplerate: samp_rate
  states: {state: disabled}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, fft_size=2**15, bandwidth=500, samplerate = 32e3, addr = "snr_meas"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='SNR Stub',   
                  in_sig = [(np.complex64, fft_size)],
                  out_sig = None 
              )
              self.addr = addr
              self.fft_size = fft_size
              self.samplerate = samplerate
              self.bandwidth = bandwidth
              self.snrAvg:float = 0.1
              
              self.snr = np.zeros(int((samplerate/fft_size)))
              self.window = int(0.5*(samplerate/fft_size)) # 0.5 s window
              self.kernel = np.ones(self.window) / self.window

              # message port setup
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          print(type(data[1][varname]), type(self.__dict__[varname]))
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):        
                      
              return 1
    addr: '"snr_meas"'
    bandwidth: 25e3
    fft_size: 2**15
    samplerate: samp_rate
  states: {}
- name: g4fsk_decoding_0
  id: g4fsk_decoding
  parameters: {}
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Gaussian filter
    interp: sps
    taps: taps.generate_taps(sps, 0.5)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Gaussian filter
    interp: sps
    taps: taps.generate_taps(sps, 0.25)
    type: fff
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1/decimation
    type: complex
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: decimation_rx
    type: complex
  states: {}
- name: p_cmd_in
  id: parameter
  parameters:
    label: cmd_port_in
    type: intx
    value: '5555'
  states: {}
- name: p_cmd_out
  id: parameter
  parameters:
    label: cmd_port_out
    type: intx
    value: '5556'
  states: {}
- name: p_data_in
  id: parameter
  parameters:
    label: data_port_in
    short_id: i
    type: intx
    value: '5558'
  states: {}
- name: p_data_out
  id: parameter
  parameters:
    label: data_port_out
    short_id: o
    type: intx
    value: '5557'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**12
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**12
    name: '"RF_in"'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: taps
  id: epy_module
  parameters:
    comment: |-
      Calculates Gaussian
      filter taps
    source_code: "import numpy as np\r\nfrom gnuradio import filter\r\n\r\ndef generate_taps(samples_per_symbol, bt):\r\n    samples_per_symbol = int(samples_per_symbol)\r\n    ntaps = 4 * samples_per_symbol\r\n    \r\n\r\n    # Generate Gaussian filter taps\r\n    gaussian_taps = filter.firdes.gaussian(\r\n        1,                       # gain\r\n        samples_per_symbol,      # symbol_rate\r\n        bt,                      # bandwidth * symbol time\r\n        ntaps                    # number of taps\r\n    )\r\n\r\n    taps = np.convolve(np.array(gaussian_taps), np.ones(samples_per_symbol))\r\n    return taps"
  states: {}
- name: th
  id: epy_module
  parameters:
    comment: |-
      Calculates the through-
      put in bps for the 
      selected modcod
    source_code: "import json\r\nimport numpy as np\r\n\r\n\r\n#file_name = r\"C:\\Users\\chri0\\Documents\\GitHub\\acm_protocol_p6\\hardware_Implementation\\phy\\physical_layer_transmitter\\MODCOD.json\"\r\nfile_name = \"/home/jonasj2001//Documents/uni/EIT6/acm_protocol_p6/hardware_Implementation/phy/physical_layer_transmitter/MODCOD.json\"\r\ndata:dict\r\nwith open(file_name, 'r') as f:\r\n    data = json.load(f)\r\n\r\ndef modcod(bw, modcod):\r\n    spectral_eff = data[modcod][\"SPECT\"]\r\n    throughput = spectral_eff * bw\r\n    return throughput\r\n"
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: usrp
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: msg_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: msg_out2
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: msg_out4
  states: {}
- name: virtual_sink_2_1_0
  id: virtual_sink
  parameters:
    stream_id: msg_out6
  states: {}
- name: virtual_sink_2_1_1
  id: virtual_sink
  parameters:
    stream_id: msg_out5
  states: {state: disabled}
- name: virtual_sink_2_1_1_0
  id: virtual_sink
  parameters:
    stream_id: msg_out5
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: bit_input
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: usrp
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: msg_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_0_1_1
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {state: disabled}
- name: virtual_source_1_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: msg_in
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: msg_out2
  states: {}
- name: virtual_source_1_1_0_1
  id: virtual_source
  parameters:
    stream_id: msg_out4
  states: {}
- name: virtual_source_1_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: msg_out5
  states: {}
- name: virtual_source_1_1_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: msg_out6
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bit_input
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: f"tcp://*:{p_cmd_out}"
    timeout: '100'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: f"tcp://*:{p_data_out}"
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:4001
    timeout: '100'
    type: complex
    vlen: '64'
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: f"tcp://localhost:{p_data_in}"
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:4000
    timeout: '100'
    type: complex
    vlen: '64'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: f"tcp://localhost:{p_cmd_in}"
    timeout: '100'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', epy_block_1_0_0, '2']
- [analog_frequency_modulator_fc_0_0, '0', epy_block_1_0_0, '1']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_1_0, '0']
- [analog_quadrature_demod_cf_1, '0', digital_symbol_sync_xx_1_0_0, '0']
- [analog_quadrature_demod_cf_2, '0', digital_symbol_sync_xx_1_0_0_0, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_1_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_null_sink_1, '0']
- [blocks_repack_bits_bb_0, '0', zeromq_rep_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_throttle2_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2_0_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_rep_sink_1, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_3, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_uchar_to_float_1_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_vco_c_0, '0', epy_block_1_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', mmse_resampler_xx_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_1_0_0_0, '2']
- [digital_binary_slicer_fb_0_0, '0', epy_block_1_0_0_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_symbol_sync_xx_1_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_1_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_symbol_sync_xx_1_0_0_0, '0', g4fsk_decoding_0, '0']
- [epy_block_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [epy_block_0, '1', digital_chunks_to_symbols_xx_0_0, '0']
- [epy_block_0, '2', digital_chunks_to_symbols_xx_0, '0']
- [epy_block_0, decim_out, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, msg_out, virtual_sink_2, '0']
- [epy_block_0, repack_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_0_0, '0', analog_quadrature_demod_cf_2, '0']
- [epy_block_0_0, '1', analog_quadrature_demod_cf_1, '0']
- [epy_block_0_0, '2', analog_quadrature_demod_cf_0, '0']
- [epy_block_0_0, decim_out, blocks_msgpair_to_var_1_0, inpair]
- [epy_block_0_0, msg_out, virtual_sink_2_1, '0']
- [epy_block_1_0_0, '0', mmse_resampler_xx_0, '0']
- [epy_block_1_0_0, msg_out, virtual_sink_2_0, '0']
- [epy_block_1_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_1_0_0_0, '0', blocks_uchar_to_float_1_0, '0']
- [epy_block_1_0_0_0, msg_out, virtual_sink_2_1_0, '0']
- [epy_block_2_0, msg_out, virtual_sink_2_1_1, '0']
- [epy_block_2_0_0, msg_out, virtual_sink_2_1_1_0, '0']
- [g4fsk_decoding_0, '0', blocks_float_to_uchar_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_vco_c_0, '0']
- [mmse_resampler_xx_0, '0', blocks_stream_to_vector_1, '0']
- [mmse_resampler_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_0, '0']
- [mmse_resampler_xx_1, '0', epy_block_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', mmse_resampler_xx_1, '0']
- [virtual_source_1, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_0, '0', epy_block_0, msg_in]
- [virtual_source_1_0_0, '0', epy_block_1_0_0, msg_in]
- [virtual_source_1_0_1, '0', epy_block_0_0, msg_in]
- [virtual_source_1_0_1_0, '0', epy_block_1_0_0_0, msg_in]
- [virtual_source_1_0_1_1, '0', epy_block_2_0, msg_in]
- [virtual_source_1_0_1_1_0, '0', epy_block_2_0_0, msg_in]
- [virtual_source_1_1, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0_1, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0_1_0, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_1_1_0_1_0_0, '0', zeromq_pub_msg_sink_0, in]
- [virtual_source_2, '0', blocks_null_sink_0, '0']
- [virtual_source_2, '0', blocks_uchar_to_float_1, '0']
- [zeromq_req_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [zeromq_req_source_1, '0', blocks_vector_to_stream_0, '0']
- [zeromq_sub_msg_source_0, out, virtual_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
