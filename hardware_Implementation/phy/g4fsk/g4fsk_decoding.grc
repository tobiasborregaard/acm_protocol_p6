options:
  parameters:
    generate_options: hb
    id: g4fsk_decoding
    output_language: python
    title: g4fsk_decoding
  states: {}

blocks:
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '6'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/4
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.75'
    init: '0'
    low: '0.75'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '2'
    init: '0'
    low: '2'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '1.75'
    init: '0'
    low: '1.75'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_add_xx_0, '2']
- [blocks_threshold_ff_0_0, '0', blocks_add_xx_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_add_const_vxx_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
