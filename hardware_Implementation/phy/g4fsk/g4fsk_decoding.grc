options:
  parameters:
    generate_options: hb
    id: g4fsk_decoding
    output_language: python
    title: g4fsk_decoding
  states: {}

blocks:
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '9'
    lo: '-0'
  states: {}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(movav)
    max_iter: int(movav)
    scale: 1/movav
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '6'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '8.5'
    init: '0'
    low: '8'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '4'
    init: '0'
    low: '4'
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: '2'
    init: '0'
    low: '2'
  states: {}
- name: movav
  id: parameter
  parameters:
    comment: Has to be int(samp_rate/interp/50)
    type: intx
    value: '10'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: railout
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: railout
  states: {}

connections:
- [analog_rail_ff_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [analog_rail_ff_0_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1_0_0_0, '0', analog_rail_ff_0_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_add_const_vxx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_sub_xx_0_0, '0', blocks_threshold_ff_0_1_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_xx_0, '2']
- [blocks_threshold_ff_0, '0', blocks_sub_xx_0, '1']
- [blocks_threshold_ff_0_1, '0', blocks_add_xx_0, '1']
- [blocks_threshold_ff_0_1, '0', blocks_sub_xx_0_0, '1']
- [blocks_threshold_ff_0_1_0, '0', blocks_add_xx_0, '0']
- [pad_source_0, '0', analog_rail_ff_0, '0']
- [virtual_source_0, '0', blocks_sub_xx_0, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
