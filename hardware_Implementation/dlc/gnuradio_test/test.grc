options:
  parameters:
    author: jonasj2001
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '50000'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt.pmt_python
      import zmq
      import pmt
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, addr = "modcod"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.hello = 1
              self.snr = 2.0
              self.modcod = "1"
              self.addr = addr
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              #self.context = zmq.Context()
              #self.socket = self.context.socket(zmq.REP)
              #self.thread = threading.Thread(target=self.input_handler)
              #self.start()

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  raise Exception("Err: Invalid format")
                  #self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    addr: '"demux"'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt.pmt_python
      import zmq
      import pmt
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, addr = "modcod"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.modcod: str = "1"
              self.addr = addr
              self.snr = 14.0
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              #self.context = zmq.Context()
              #self.socket = self.context.socket(zmq.REP)
              #self.thread = threading.Thread(target=self.input_handler)
              #self.start()

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def input_handler(self):
              #self.socket.bind(self.ip)
              return

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    addr: '''snr_meas'''
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt.pmt_python
      import zmq
      import pmt
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, addr = "modcod"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.hello = 1
              self.snr = 2.0
              self.modcod = "1"
              self.addr = addr
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              #self.context = zmq.Context()
              #self.socket = self.context.socket(zmq.REP)
              #self.thread = threading.Thread(target=self.input_handler)
              #self.start()

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  raise Exception("Err: Invalid format")
                  #self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    addr: '"demux_1"'
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt.pmt_python
      import zmq
      import pmt
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, addr = "modcod"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.hello = 1
              self.snr = 2.0
              self.modcod = "1"
              self.addr = addr
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              #self.context = zmq.Context()
              #self.socket = self.context.socket(zmq.REP)
              #self.thread = threading.Thread(target=self.input_handler)
              #self.start()

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  raise Exception("Err: Invalid format")
                  #self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    addr: '"mux_1"'
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt.pmt_python
      import zmq
      import pmt
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, addr = "modcod"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.hello = 1
              self.snr = 2.0
              self.modcod = "1"
              self.addr = addr
              self.message_in = 'msg_in'
              self.message_port_register_in(pmt.intern(self.message_in))
              self.set_msg_handler(pmt.intern(self.message_in), self.mailbox)
              self.message_out = 'msg_out'
              self.message_port_register_out(pmt.intern(self.message_out))

              #self.context = zmq.Context()
              #self.socket = self.context.socket(zmq.REP)
              #self.thread = threading.Thread(target=self.input_handler)
              #self.start()

          def extract_pmt(self, msg):
              try:
                  data = pmt.to_python(msg)
              except:
                  raise Exception("Err: Invalid format")
                  #self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt("Err: Invalid format"))
              
              return data

          def unpack(self, msg):
              if msg[0] == self.addr:
                  return msg[1:]
              else: return False


          def mailbox(self, msg):
              r = {}
              try:
                  data = self.extract_pmt(msg)

                  #If address check is active:
                  data = self.unpack(data)
                  if data == False: return 

                  varname = list(data[1].keys())[0]
                  if varname not in self.__dict__:
                      raise Exception("Err: Unknown variable")
                  
                  if data[0].lower() == "get":
                      r[varname] = self.__dict__[varname]
                  elif data[0].lower() == "set":
                      if type(data[1][varname]) != type(self.__dict__[varname]):
                          raise Exception("Err: Variable in wrong format")
                      else:
                          self.__dict__[varname] = data[1][varname]
                          r[varname] = "ok"
                  
                  #If address return with SRC
                  r = [self.addr, r]

                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(r))
                  return

              except Exception as e:
                  self.message_port_pub(pmt.intern(self.message_out), pmt.to_pmt(str(e)))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    addr: '"mux"'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:5557
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5558
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
  states: {}

connections:
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [epy_block_0, msg_out, zeromq_pub_msg_sink_0, in]
- [epy_block_0_0, msg_out, zeromq_pub_msg_sink_0, in]
- [epy_block_0_1, msg_out, zeromq_pub_msg_sink_0, in]
- [epy_block_0_1_0, msg_out, zeromq_pub_msg_sink_0, in]
- [epy_block_0_2, msg_out, zeromq_pub_msg_sink_0, in]
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_sub_msg_source_0, out, epy_block_0_0, msg_in]
- [zeromq_sub_msg_source_0, out, epy_block_0_1, msg_in]
- [zeromq_sub_msg_source_0, out, epy_block_0_1_0, msg_in]
- [zeromq_sub_msg_source_0, out, epy_block_0_2, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
